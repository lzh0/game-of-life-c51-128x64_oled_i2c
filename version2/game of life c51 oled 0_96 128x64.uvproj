# Keil uVision project game of life c51 oled 0_96 128x64.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: game of life c51 oled 0_96 128x64 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib\oled
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Lib
    ./Lib/oled/: oled.c
